# Keil uVision project NONZ_RTOS.uvprojx, settings and files
target NONZ_RTOS Configuration (ARM-ADS)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.4.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: NONZ_RTOS Configuration
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER
  c include: ..\Inc; ..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy; ..\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM4F; ..\Middlewares\Third_Party\FreeRTOS\Source\include; ..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; ..\Drivers\CMSIS\Include; ..\Drivers\CMSIS\Device\ST\STM32F4xx\Include
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: list.c event_groups.c tasks.c queue.c timers.c croutine.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_gpio.c stm32f4xx_hal_adc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_pcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rcc.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_ll_usb.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_spi.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Application/User
    ../Src/: stm32f4xx_hal_msp.c dma.c i2c.c gpio.c adc.c tim.c usb_otg.c spi.c stm32f4xx_it.cpp freertos.cpp main.cpp Retarget.c
  group Tasks
    ../Src/_Tasks/: TSK500mls.cpp TSK1000mls.cpp TSKSpi1.cpp TSKSpi2.cpp TSKRC.cpp Task5mls.cpp
  group Object Definitions
    ../Src/_Objects_Definitions/: ObjectsDefinitions.cpp
  group ADC
    ../Src/_ADC/: ADC.cpp
  group Analog Sensors
    ../Src/_AnalogSensors/: AnalogSensors.cpp
  group BMS
    ../Src/_BMS/: BMS.cpp
  group DSP Tools
    ../Src/_DSP_tools/: Filters.cpp
  group Menu Items
    ../Src/_Menu_Items/: Parameters.cpp DisplayLed4Digit.cpp DisplayLedDecoder.cpp Editor.cpp Engine.cpp MainMenu.cpp
  group PWM
    ../Src/_PWM/: PWM_User.cpp PWM.cpp
  group RC
    ../Src/_RC/: RC_Decoder.cpp RC.cpp
  group SPI Handler
    ../Src/_SPI_Handler/: SPI_Handler.cpp
  group SPI port PIC
    ../Src/_SPI_Port_PIC/: SPI_Port_PIC.cpp
  group MRAM
    ../Src/_MRAM/: Mram.cpp
